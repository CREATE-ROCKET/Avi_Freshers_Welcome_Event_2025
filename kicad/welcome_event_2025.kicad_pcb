# Repository CREATE-ROCKET/Avi_Freshers_Welcome_Event_2025

File README.md:

# CREATE電装班の2025年度新歓イベント用資料です。
## 右上の緑色の「<>Code」を選択して、「Download ZIP」を押してZipファイルをダウンロードしてください。

## KiCad design kicad/welcome_event_2025.kicad_pcb

Parts:
AFF1: LTS-6960HR; 7SegmentLED_LTS6760_LTS6780
C1, C4, C5: C; D_0603_1608Metric
C2: 0.33μ; R_0603_1608Metric
C3: 2.2μF; R_0603_1608Metric
D1: LED; LED_D3.0mm_FlatTop
J2: USB_A
R1, R2, R3, R4, R5, R6, R7, R9, R11: R; D_0603_1608Metric
R8, R10, R12: R; C_0603_1608Metric
SW1, SW2, SW3: SW_MEC_5E; SW_PUSH_6mm_H7.3mm
U2: CH32V203K8T6; LQFP-32_7x7mm_P0.8mm
U3: RT9742BNGJ5F; TSOT-23-5_HandSoldering

Connections:
+3.3V: AFF1.3 (C.A.), AFF1.8 (C.A.), C1.1, C3.1, C4.1, R11.1, SW1.1, SW1.2, SW2.3 (K), SW2.4 (A), U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD), U3.5 (VOUT)
/D+: J2.3 (D+), U2.22 (PA12/USB1DP)
/D-: J2.2 (D-), U2.21 (PA11/USB1DM)
/LED_dot: R12.2, U2.26 (PB3)
/led: R8.1, U2.14 (PB0/ADC8)
/led1: R5.2, U2.7 (PA1/ADC1)
/led2: R4.2, U2.8 (PA2/ADC2)
/led4: R3.2, U2.10 (PA4/ADC4)
/led6: R2.2, U2.12 (PA6/ADC6)
/led7: R1.2, U2.13 (PA7/ADC7)
/led9: R6.2, U2.20 (PA10)
/led10: R7.2, U2.19 (PA9)
/switch: SW1.4 (A), U2.15 (PB1/ADC9)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (K), J2.4 (GND), J2.5 (Shield), R9.1, R10.1, SW3.3 (K), SW3.4 (A), U2.16 (VSS), U2.32 (VSS), U3.2 (GND), U3.4 (NC)
unnamed: AFF1.5 (DP), R12.1
unnamed: AFF1.7 (a), R1.1
unnamed: AFF1.6 (b), R2.1
unnamed: AFF1.4 (c), R3.1
unnamed: AFF1.2 (d), R4.1
unnamed: AFF1.1 (e), R5.1
unnamed: AFF1.9 (f), R6.1
unnamed: AFF1.10 (g), R7.1
unnamed: D1.2 (A), R8.2
unnamed: C2.1, J2.1 (VBUS), U3.1 (VIN), U3.3 (~EN)
unnamed: R10.2, SW1.3 (K)
unnamed: C5.1, R11.2, SW3.1, SW3.2, U2.4 (NRST)
unnamed: R9.2, SW2.1, SW2.2, U2.31 (PB8/BOOT0)

Notes on the sheet:
スイッチ
USB
LED
CH32V203K8T6
7セグ

Board: 2 copper layers, 31.0 x 36.5 mm, 25 parts (6 on the bottom side), 27 nets.

## Code that names these connections

File code/99.参考/blinkLED/blinkLED.ino:

#define LED PB0
#define LEDA PA7
#define LEDB PA6
#define LEDC PA4
#define LEDD PA2
#define LEDE PA1
#define LEDF PA10
#define LEDG PA9
#define BUTTON PB1

void setup() {
  pinMode(LED, OUTPUT);
  pinMode(LEDA, OUTPUT);
  pinMode(LEDB, OUTPUT);
  pinMode(LEDC, OUTPUT);
  pinMode(LEDD, OUTPUT);
  pinMode(LEDE, OUTPUT);
  pinMode(LEDF, OUTPUT);
  pinMode(LEDG, OUTPUT);
  pinMode(BUTTON, INPUT);
  digitalWrite(LED, LOW);
  digitalWrite(LEDA, HIGH);
  digitalWrite(LEDB, HIGH);
  digitalWrite(LEDC, HIGH);
  digitalWrite(LEDD, HIGH);
  digitalWrite(LEDE, HIGH);
  digitalWrite(LEDF, HIGH);
  digitalWrite(LEDG, HIGH);
}

void loop() {
  digitalWrite(LED, HIGH);
  delay(1000);
  digitalWrite(LED, LOW);
  delay(1000);
}

## Commit log

2025-04-02 init commit
2025-04-02 [add] kicad projects
2025-04-07 [add] always_on code
2025-04-16 スライド追加
2025-04-16 [change] directory structure
2025-04-16 [doc] add photo
